# IAR project code.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: ..\..\..\STM_SDK\STM8S_StdPeriph_Lib\Libraries\STM8S_StdPeriph_Driver\inc; $PROJ_DIR$
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: code.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c main.h stm8s_it.c
  group LIB
    ../../../STM_SDK/STM8S_StdPeriph_Lib/Libraries/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c
